# IAR project secure-serial-usb-bootloader.ewp, settings and files
configuration Normal (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\INC\DLib_Config_Normal.h
  General.OGChipSelectEditMenu: default None
  ICCARM.CCDefines: PLATFORM_HEADER="../../platform/base/hal/micro/cortexm3/compiler/iar-boot.h"; EMBER_STACK_CAN_MULTIMAC; HAL_MICRO; CORTEXM3; CORTEXM3_EM3588; PHY_NULL; BOARD_DEV0680ETM; BOARD_HEADER="../../platform/base/hal/micro/cortexm3/em35x/board/dev0680etm.h"; CORTEXM3_EMBER_MICRO; MAX_RADIO_POWER=0; BTL_HAS_SERIAL; BOOTLOADER; BOOTLOADER_TYPE=BL_EXT_TYPE_SERIAL_USB; EMBER_SERIAL3_MODE=EMBER_SERIAL_FIFO; EMBER_SERIAL3_TX_QUEUE_SIZE=128; EMBER_SERIAL3_RX_QUEUE_SIZE=256; EMBER_SERIAL3_BLOCKING; BOOTLOADER_USB; __SOURCEFILE__="$FILE_FNAME$"
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.IExtraOptions: --no_path_in_file_macros; --separate_cluster_for_initialized_variables
  ICCARM.CCIncludePath2: $FILE_DIR$\; ..\..\..\; ..\..\..\STACK\; ..\..\..\..\..\platform\base\HAL\; ..\..\..\..\..\platform\base\; ../../../../../platform/CMSIS/Include; ../../../../../platform/Device/SiliconLabs/em358x/Include/; ../../../../../platform/radio/rail_lib/plugin; ../../../../../platform/radio/rail_lib/plugin/coexistence/common; ../../../../../platform/radio/rail_lib/plugin/coexistence/hal/em3xx/; ../../../../../platform/base/hal/micro/cortexm3/common; ../../../../../platform/base/hal/plugin; ../../../../../platform/radio/rail_lib/plugin; ../../../app/util; ../../../../../platform/radio/mac; ../../../../../util/silicon_labs/silabs_core/event_control; ../../../../../util/silicon_labs/silabs_core; ../../../../../platform/base/lwip/; ../../../../../platform/base/lwip/src/include/; ../../../../../platform/base/lwip/contrib/port/FreeRTOS/EM358X/; ../../../../../platform/base/lwip/src/include/ipv4/; ../../../../../platform/base/lwip/src/include/ipv6/; ../../../app/test/micrium_cfg/; ../../../../../platform/micrium_os; ../../../../../platform/micrium_os/bsp/include; ../../../../../platform/micrium_os/kernel/include; ../../../../../platform/micrium_os/common/include; ../../../../../platform/micrium_os/bsp/siliconlabs/generic/include
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  AARM.ADefines: PLATFORM_HEADER="../../platform/base/hal/micro/cortexm3/compiler/iar-boot.h"; EMBER_STACK_CAN_MULTIMAC; HAL_MICRO; CORTEXM3; CORTEXM3_EM3588; PHY_NULL; BOARD_DEV0680ETM; BOARD_HEADER="../../platform/base/hal/micro/cortexm3/em35x/board/dev0680etm.h"; CORTEXM3_EMBER_MICRO; MAX_RADIO_POWER=0; BTL_HAS_SERIAL; BOOTLOADER; BOOTLOADER_TYPE=BL_EXT_TYPE_SERIAL_USB; EMBER_SERIAL3_MODE=EMBER_SERIAL_FIFO; EMBER_SERIAL3_TX_QUEUE_SIZE=128; EMBER_SERIAL3_RX_QUEUE_SIZE=256; EMBER_SERIAL3_BLOCKING; BOOTLOADER_USB
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: secure-serial-usb-bootloader.s37
  postbuild: "$_ISA3_UTILS_DIR_$\em3xx_convert.exe" "$TARGET_BPATH$.s37" "$TARGET_BPATH$.ebl"
  ILINK.IlinkOutputFile: secure-serial-usb-bootloader.out
  ILINK.IlinkConfigDefines: HEADER_SIZE=256; BOOTLOADER=1; FLASH_SIZE=1M; RAM_SIZE=256K
  ILINK.IlinkIcfFile: ../../../../../platform/base/hal/micro/cortexm3/em35x/em3588/iar-cfg.icf
  ILINK.IlinkProgramEntryLabel: halEntryPoint
  group (top)
    ../../../../../platform/base/hal/micro/cortexm3/bootloader/: bootloader-gpio.c bootloader-usb.c cstartup-iar-boot-entry.s79 cstartup-iar-boot.c
    ../../../../../platform/base/hal/micro/cortexm3/usb/cdc/: callbacks.c descriptors.c
    ../../../../../platform/base/hal/micro/generic/: crc.c mem-util.c random.c
    ../../../../../platform/base/hal/micro/cortexm3/usb/: em_usbd.c em_usbdch9.c em_usbdep.c em_usbhal.c em_usbint.c em_usbtimer.c
    ../../../../../platform/base/hal/plugin/serial/: ember-printf.c serial.c
    ../../../../../platform/base/hal/micro/cortexm3/: isr-stubs.s79 led.c mfg-token.c micro-common.c uart.c
    ../../../build/secure-usb-standalone-bootloader-library-cortexm3-iarboot-em3588-null/: secure-usb-standalone-bootloader-library.a
    ../../../../../platform/base/hal/micro/cortexm3/common/: standalone-bootloader-custom.c
